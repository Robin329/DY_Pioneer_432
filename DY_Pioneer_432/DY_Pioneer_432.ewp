# IAR project DY_Pioneer_432.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432E401Y TexasInstruments MSP432E401Y
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include; -DDeviceFamily_MSP432E4; -D__MSP432E401Y__; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: D:\work\DY_Pioneer_432\SRC\fc_general; D:\work\DY_Pioneer_432\SRC\applications; D:\work\DY_Pioneer_432\SRC\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DeviceFamily_MSP432E4; __MSP432E401Y__
  AARM.AUserIncludes: $PROJ_DIR$; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include
  OBJCOPY.OOCOutputFile: DY_Pioneer_432.srec
  ILINK.IlinkOutputFile: DY_Pioneer_432.out
  ILINK.IlinkIcfFile: msp432e401y.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4f/spiffs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_msp432e4.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4f/fatfs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/devices/msp432e4/driverlib/lib/iar/m4f/msp432e4_driverlib.a; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    SRC/applications/: BSP_Init.c include.h main.c
  group DRIVE
    SRC/drivers/: Drv_pwm_out.c Drv_time.c Drv_usart.c pinout.c uartstdio.c
  group FC_GENERAL
    SRC/fc_general/: DY_FcData.c
  group LIBRARY
    ./: startup_msp432e401y_ewarm.c system_msp432e401y.c
